Properties of the parts of a building model (IFC4)

# File
Description: Druck-Messumformer, 250/500/750/1000 Pa, 0-10 V, 2-10 V, 0-20 mA, 4-20 mA, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9270010, Druck-Messumformer, 250/500/750/1000 Pa, 0-10 V, 2-10 V, 0-20 mA, 4-20 mA
In: Raum
Description: Die mikroprozessorgesteuerten Druckmessumformer eignen sich zur Erfassung von Über-, Unter- oder Differenzdruck von nichtaggressiven Gasen. Sie kommen sowohl bei Heizungs-, Lüftungs- oder Klimaanwendungen, als auch in der Reinraumtechnik oder der Feinzugmessung zum Einsatz. Die Druckmessung erfolgt über einen piezoresistiven Drucksensor. Das Material der mediumberührenden Teile ist Ni, PU, Al, Au, Pyrex Glas, Silikon, Kovar, Duraplast, Ultem Plastic. Die Zeitkonstante ist zwischen ca. 10 ms, 2 s oder 4 s umschaltbar. Beim diesem Gerät kann zwischen den relativen Messbereichen ±1000 Pa, ±750 Pa, ±500 Pa und ±250 Pa gewählt werden.; Classification: EC002989 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9270010; ModelLabel: MDEKD-940.000; GlobalTradeItemNumber: 4050528043917; ProductURL: https://alre.de/produkt_G9270010
Pset_Specification - NominalLength: 0.086 m; NominalWidth: 0.076 m; NominalDepth: 0.04 m; NetWeight: 0.091
Pset_ALRE_ETIM_Properties - Gewicht: 0.091; Messbereich: 0; Umgebungstemperatur: 0; Analogausgang 0 V ... 10 V: yes; Analogausgang 0 mA ... 20 mA: yes; Analogausgang 4 mA ... 20 mA: yes; Prozesstemperatur: 0; Analogausgang 0 V ... 2 V: no; Analogausgang 0 V ... 5 V: no; Analogausgang 2 V ... 10 V: yes; ETIM-Klasse: EC002989; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9270010.pdf
